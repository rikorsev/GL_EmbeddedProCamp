# IAR project project.ewp, settings and files
configuration STM32F334x8 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F334x8 ST STM32F334x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F334x8
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Include; ..\..\..\Libraries\CMSIS\Device\ST\STM32F30x\Include; ..\..\..\Libraries\STM32F30x_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32F30x_I2C_CPAL_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f334x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F302x8 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F302x8 ST STM32F302x8
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F302x8
  ILINK.IlinkIcfFile: stm32f302x8_flash.icf
configuration STM32F303xC (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F303xC ST STM32F303xC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F303xC; USE_STM32303C_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Include; ..\..\..\Libraries\CMSIS\Device\ST\STM32F30x\Include; ..\..\..\Libraries\STM32F30x_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32F30x_I2C_CPAL_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM32303C_EVAL
  ILINK.IlinkIcfFile: stm32f303xc_flash.icf
configuration STM32F303xE (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F303xE ST STM32F303xE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F303xE; USE_STM32303C_EVAL
  ICCARM.CCIncludePath2: as above
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/iar/: startup_stm32f302x8.s startup_stm32f303xc.s startup_stm32f303xe.s startup_stm32f334x8.s
  group STM32F30x_StdPeriph_Driver
    ../../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_fmc.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group User
    ../: main.c stm32f30x_it.c system_stm32f30x.c
